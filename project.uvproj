# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: project
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 BSE_Main.C LIB_BSE_INT_Ext.C LIB_BSE_GPIO.C LIB_BSE_Timers.c LIB_BSE_Config_Globale.c LIB_BSE_UART.c LIB_BSE_ADC.c LIB_BSE_DAC.C
